## boards/shields/ocreeb_12/Kconfig.defconfig
```kconfig
if SHIELD_OCREEB_12

config ZMK_KEYBOARD_NAME
    default "ocreeb-12"

endif # SHIELD_OCREEB_12
```
